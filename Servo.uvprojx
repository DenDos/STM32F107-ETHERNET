# Keil uVision project Servo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test1 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\STM32_SPL\inc;.\STM32_SPL\src;.\STM32_CMSIS;.\STM32_CMSIS\DeviceSupport\ST\STM32F10x;.\STM32_CMSIS\CoreSupport;..\test;.\My_Libs;.\ETH\Libraries\STM32_ETH_Driver\src;.\ETH\Libraries\STM32_ETH_Driver\inc;.\ETH\inc;.\ETH\src;.\ETH\Utilities\efsl\include;.\ETH\Utilities\efsl\include\interface;.\ETH\Utilities\efsl\source\interface;.\STM32_CMSIS\DeviceSupport\ST\STM32F10x;.\ETH\Utilities\STM32_EVAL;.\ETH\Utilities\STM32_EVAL\STM3210C_EVAL;.\ETH\Utilities\lwip-1.3.1\port;.\ETH\Utilities\lwip-1.3.1\port\arch\junk;.\ETH\Utilities\lwip-1.3.1\src\include\lwip;.\ETH\Utilities\lwip-1.3.1\src\include;.\ETH\Utilities\lwip-1.3.1\src\include\ipv4\lwip;.\ETH\Utilities\lwip-1.3.1\port\arch;.\ETH\Utilities\lwip-1.3.1\port;.\ETH\Utilities\efsl\include;.\ETH\Utilities\efsl\include\interface;.\ETH\cJSON
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./: main.c
    ./STM32_CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group CMSIS
    ./STM32_CMSIS/CoreSupport/: core_cm3.c
    ./STM32_CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./STM32_CMSIS/: stm32f10x_conf.h
  group STDPeriph
    ./STM32_SPL/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MyLib
    ./My_Libs/: InitS.c InitS.h Set_angle.c Set_angle.h Delay.c
    ./: Math.c
  group ETH_DRIVER
    ./ETH/Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group EVAL
    ./ETH/Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_ioe.c stm3210c_eval_lcd.c
    ./ETH/Utilities/STM32_EVAL/: stm32_eval.c
  group User
    ./ETH/Utilities/lwip-1.3.1/port/: ethernetif.c client.c helloworld.c httpd.c server.c tftpserver.c tftputils.c
    ./ETH/Utilities/lwip-1.3.1/src/netif/: etharp.c
    ./ETH/src/: netconf.c stm32f10x_it.c stm32f107.c
  group LwIp
    ./ETH/Utilities/lwip-1.3.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ./ETH/Utilities/lwip-1.3.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ./ETH/Utilities/lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group EFSL
    ./ETH/Utilities/efsl/source/: dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
    ./ETH/Utilities/efsl/source/interface/: sd.c sd_stm32.c
